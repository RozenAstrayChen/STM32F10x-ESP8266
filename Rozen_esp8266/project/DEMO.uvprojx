# Keil uVision project DEMO.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS;..\..\STM32F10x_StdPeriph_Driver\inc;..\User\Common;..\User\delay;..\User\ESP8266;..\User\my_uart;..\User\SysTick;..\User\usart;..\User\LED;..\User\control;..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c stm32f10x_it.c
  group DRIVER
    ../../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group My_lib
    ../User/Common/: Common.c
    ../User/delay/: delay.c
    ../User/ESP8266/: bsp_esp8266.c
    ../User/my_uart/: usart.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/usart/: bsp_usart1.c
    ../User/LED/: led.c
    ../User/control/: control.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
